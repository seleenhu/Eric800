# Keil uVision project project.uvprojx, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429BI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp\inc;..\..\User\bsp;..\..\User;..\..\User\fonts;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\emWin\Config;..\..\emWin\emWinEric800;..\..\User\sdio;..\..\User\FatFS\src;..\..\User;..\..\User\fft;..\..\User\arithmetic;..\..\User\Ethernet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c mydefine.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c stm32f4xx_assert.c
    ../../User/bsp/src/: bsp_dwt.c bsp_timer.c bsp_ext_io.c bsp_uart_fifo.c bsp_tim_pwm.c bsp_fmc_sdram.c bsp_i2c_gpio.c bsp_sdio_sd.c bsp_InOut.c bsp_rtc.c bsp_spi_bus.c bsp_spi_flash.c bsp_RS485.c bsp_rf433.c bsp_4G.c bsp_syn6288.c bsp_buzzer.c bsp_moduletomodule.c bsp_UIS891X.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_fmc.c stm32f4xx_tim.c stm32f4xx_ltdc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_iwdg.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group Fonts
    ../../User/fonts/: asc12.c asc16.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group LCD_Driver
    ../../User/bsp/src/: param.c bsp_tft_lcd.c bsp_tft_429.c bsp_touch.c bsp_gt811.c bsp_ts_ft5x06.c TOUCH_STMPE811.c
  group GUI_X
    ../../emWin/GUI_X/: GUI_X.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_Template.c LCDConf_Lin_Template.h
  group GUI/DEMO
    ../../emWin/emWinTask/: MainTask.c MainTask.h
    ../../emWin/emWinEric800/: font.c FontSong16.c StartDLG.c aboutusDLG.c MainDLG.c buttonbmp.c Calibration_SDLG.c CalibrationDLG.c Communication_SDLG.c Cupboard_SDLG.c Device_SDLG.c Ground_ADLG.c LeakageCurrent_SDLG.c InitSystem.c Main_GraphDLG.c NumPadDLG.c OverVoltage_ADLG.c passwordDLG.c PowerQualityDLG.c Protector_WDLG.c PTCT_SDLG.c PTOpen_ADLG.c Resonance_ADLG.c Temp&Humdity_SDLG.c TempHumdity_WDLG.c TempHumidity_ADLG.c UnderVoltage_ADLG.c voltageLimit_S.c Short_ADLG.c OutPutTest_SDLG.c
    ../../emWin/emWinERIC800/: WaveSelectDLG.c Vetor_ADLG.c MainDLG_messge.c WaveSelectGndDLG.c SeletctGndCurrentWave_ADLG.c
  group GUI/Lib
    ../../emWin/GUILib/: STemWin532_CM4_Keil_ot.lib
  group FatFS
    ../../User/FatFS/src/: diskio.c ff.c
  group Ethernet
    ../../User/Ethernet/: socket.c utility.c w5500.c w5500_config.c
  group Doc
    ../../Doc/: redeme.txt
software components: CMSIS:CORE 5.0.1
