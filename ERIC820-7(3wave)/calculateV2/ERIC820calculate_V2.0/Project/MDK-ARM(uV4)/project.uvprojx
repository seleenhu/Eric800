# Keil uVision project project.uvprojx, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429BI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp\inc;..\..\User\bsp;..\..\User;..\..\User\fonts;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\emWin\Config;..\..\emWin\emWinEric800;..\..\User\sdio;..\..\User\FatFS\src;..\..\User;..\..\User\fft;..\..\User\arithmetic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c mydefine.c
    ../../User/fft/: cr4_fft_256_stm32.s cr4_fft_64_stm32.s
    ../../User/arithmetic/: arithmetic.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c stm32f4xx_assert.c
    ../../User/bsp/src/: bsp_dwt.c bsp_timer.c bsp_ext_io.c bsp_tim_pwm.c bsp_fmc_sdram.c bsp_i2c_gpio.c bsp_sdio_sd.c bsp_InOut.c bsp_rtc.c bsp_ad7606.c bsp_spi_bus.c bsp_spi_flash.c bsp_fi.c bsp_moduletomodule.c bsp_nand_flash.c bsp_RS485.c bsp_can.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_fmc.c stm32f4xx_tim.c stm32f4xx_ltdc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_iwdg.c stm32f4xx_can.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group Doc
    ../../Doc/: redeme.txt
  group FatFS
    ../../User/FatFS/src/: diskio.c ff.c
    ../../User/FatFS/src/option/: cc936.c
software components: CMSIS:CORE 5.0.1
